<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\zigbee_multi_sensor_freertos_pca10056.ewp</path>
  </project>  <batchBuild/>
</workspace>