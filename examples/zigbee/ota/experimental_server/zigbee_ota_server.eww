<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\zigbee_ota_server_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\s140\iar\zigbee_ota_server_pca10056_s140.ewp</path>
  </project>  <batchBuild/>
</workspace>