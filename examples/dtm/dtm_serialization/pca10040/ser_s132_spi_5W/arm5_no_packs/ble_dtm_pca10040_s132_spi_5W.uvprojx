# Keil uVision project ble_dtm_pca10040_s132_spi_5W.uvprojx, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=6 S132 SPI_MASTER_0_ENABLE SVCALL_AS_NORMAL_FUNCTION SWI_DISABLE0 SWI_DISABLE3 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\serialization\application\codecs\ble\serializers;..\..\..\..\..\..\components\serialization\application\codecs\common;..\..\..\..\..\..\components\serialization\application\hal;..\..\..\..\..\..\components\serialization\application\transport;..\..\..\..\..\..\components\serialization\common;..\..\..\..\..\..\components\serialization\common\struct_ser\ble;..\..\..\..\..\..\components\serialization\common\transport;..\..\..\..\..\..\components\serialization\common\transport\ser_phy;..\..\..\..\..\..\components\serialization\common\transport\ser_phy\config;..\..\..\..\..\..\components\softdevice\common;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\..\modules\nrfx\mdk;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_SD_BLE_API_VERSION=6,-DS132,-DSPI_MASTER_0_ENABLE,-DSVCALL_AS_NORMAL_FUNCTION,-DSWI_DISABLE0,-DSWI_DISABLE3,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
    ../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../../../../components/drivers_nrf/spi_master/: spi_5W_master.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Serialization
    ../../../../../../components/serialization/application/codecs/ble/serializers/: app_ble_gap_sec_keys.c app_ble_user_mem.c ble_app.c ble_event.c ble_evt_app.c ble_gap_app.c ble_gap_evt_app.c ble_gattc_app.c ble_gattc_evt_app.c ble_gatts_app.c ble_gatts_evt_app.c ble_l2cap_app.c ble_l2cap_evt_app.c nrf_soc_app.c
    ../../../../../../components/serialization/application/codecs/ble/middleware/: app_mw_ble.c app_mw_ble_gap.c app_mw_ble_gattc.c app_mw_ble_gatts.c app_mw_ble_l2cap.c app_mw_nrf_soc.c
    ../../../../../../components/serialization/application/codecs/common/: ble_dtm_app.c ble_dtm_init.c
    ../../../../../../components/serialization/common/struct_ser/ble/: ble_gap_struct_serialization.c ble_gatt_struct_serialization.c ble_gattc_struct_serialization.c ble_gatts_struct_serialization.c ble_l2cap_struct_serialization.c ble_struct_serialization.c nrf_soc_struct_serialization.c
    ../../../../../../components/serialization/common/: ble_serialization.c cond_field_serialization.c ser_dbg_sd_str.c
    ../../../../../../components/serialization/application/hal/: ser_app_hal_nrf5x.c ser_app_power_system_off.c
    ../../../../../../components/serialization/common/transport/: ser_hal_transport.c
    ../../../../../../components/serialization/common/transport/ser_phy/: ser_phy_spi_5W_master.c
    ../../../../../../components/serialization/application/transport/: ser_sd_transport.c ser_softdevice_handler.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.24.1
