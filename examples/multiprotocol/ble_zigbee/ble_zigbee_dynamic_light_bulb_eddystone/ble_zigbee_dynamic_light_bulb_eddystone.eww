<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10059\s140\iar\ble_zigbee_dynamic_light_bulb_eddystone_pca10059_s140.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056\s140\iar\ble_zigbee_dynamic_light_bulb_eddystone_pca10056_s140.ewp</path>
  </project>  <batchBuild/>
</workspace>