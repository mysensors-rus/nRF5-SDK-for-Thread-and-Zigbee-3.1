<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\s140\iar\ble_thread_dyn_mtd_coap_cli_nfc_pca10056_s140.ewp</path>
  </project>  <batchBuild/>
</workspace>