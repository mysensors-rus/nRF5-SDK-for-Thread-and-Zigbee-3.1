<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\thread_cli_mtd_usb_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10059\mbr\iar\thread_cli_mtd_usb_pca10059_mbr.ewp</path>
  </project>  <batchBuild/>
</workspace>