<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10056\blank\iar\thread_cli_mtd_uart_pca10056.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10056e\blank\iar\thread_cli_mtd_uart_pca10056e.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\pca10068_nrf52811\blank\iar\thread_cli_mtd_uart_pca10068_nrf52811.ewp</path>
  </project>  <batchBuild/>
</workspace>